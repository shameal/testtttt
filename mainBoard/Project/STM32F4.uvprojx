# Keil uVision project STM32F4.uvprojx, settings and files
target STM32F4 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries;..\User;..\BSP;..\MPU6050;..\HMC5883
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: stm32f4xx_it.c main.c main.h can_bus_task.c can_bus_task.h control_task.c control_task.h remote_task.c remote_task.h
  group MPU6050
    ../MPU6050/: mpu6050_driver.c mpu6050_driver.h mpu6050_i2c.c mpu6050_i2c.h mpu6050_interrupt.c mpu6050_interrupt.h imu.c imu.h
  group BSP
    ../BSP/: bsp.c bsp.h can2.c can2.h usart1.c usart1.h delay.c delay.h led.c led.h pwm.c pwm.h usart3.c usart3.h timer.c timer.h
  group Libraries
    ../Libraries/: misc.c stm32f4xx_tim.c stm32f4xx_rcc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_syscfg.c system_stm32f4xx.c startup_stm32f4xx.s stm32f4xx_i2c.c stm32f4xx_wwdg.c stm32f4xx_flash.c stm32f4xx_dma.c
software components: CMSIS:CORE 5.0.0
